options:
  parameters:
    author: Maria_Natalia
    category: '[Modulos_D1A]'
    copyright: UIS
    generate_options: qt_gui
    id: PWM_compara
    output_language: python
    title: Compara
  states: {}

blocks:
- name: A1
  id: variable_qtgui_range
  parameters:
    label: a
    start: '-1'
    step: '10e-3'
    stop: '1'
    value: '1'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: offset
    start: '-2'
    step: '10e-3'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: signal1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: signal2
  id: analog_sig_source_x
  parameters:
    amp: 2*A1
    freq: 10e3
    offset: offset-A1
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: time
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', time, '2']
- [blocks_throttle_0, '0', time, '0']
- [signal1, '0', ModulosEfren_Compara_0, '0']
- [signal1, '0', blocks_throttle_0, '0']
- [signal2, '0', ModulosEfren_Compara_0, '1']
- [signal2, '0', time, '1']

metadata:
  file_format: 1
